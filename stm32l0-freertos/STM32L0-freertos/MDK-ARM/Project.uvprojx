# Keil uVision project Project.uvprojx, settings and files
target STM32L031K6_NUCLEO (ARM-ADS)
  device: STM32L031K6 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L031K6_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L031xx,USE_STM32L0XX_NUCLEO_32,USE_HAL_DRIVER
  c misc: --C99
  c include: ../../../../../../Drivers/BSP/STM32L0xx_Nucleo_32;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\STM32L0xx_HAL_Driver\Inc;..\Inc;..\freertos\include;..\freertos\portable\RVDS\ARM_CM0;..\Bsp;..\STM32L0xx_HAL_Driver;..\STM32L0xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32l031xx.s
  group Freertos_core
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Freertos_portable
    ../freertos/portable/RVDS/ARM_CM0/: port.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/include/: FreeRTOSConfig.h
  group BSP
    ../Bsp/: stm32l0xx_nucleo_32.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Example/User
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c uart_demo.c
  group Drivers/STM32L0xx_HAL_Driver
    ../STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal.c stm32l0xx_hal_tim.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c
software components: CMSIS:CORE 4.3.0
